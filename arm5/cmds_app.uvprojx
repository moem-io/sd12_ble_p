# Keil uVision project cmds_app.uvprojx, settings and files
target nrf51422_xxac (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD NRF51422 BOARD_PCA10028 S130 NRF_SD_BLE_API_VERSION=2 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\sdk_root\components;..\sdk_root\components\ble\ble_db_discovery;..\sdk_root\components\ble\ble_advertising;..\sdk_root\components\ble\ble_dtm;..\sdk_root\components\ble\ble_racp;..\sdk_root\components\ble\ble_services\ble_ancs_c;..\sdk_root\components\ble\ble_services\ble_ans_c;..\sdk_root\components\ble\ble_services\ble_bas;..\sdk_root\components\ble\ble_services\ble_bas_c;..\sdk_root\components\ble\ble_services\ble_cscs;..\sdk_root\components\ble\ble_services\ble_cts_c;..\sdk_root\components\ble\ble_services\ble_dfu;..\sdk_root\components\ble\ble_services\ble_dis;..\sdk_root\components\ble\ble_services\ble_gls;..\sdk_root\components\ble\ble_services\ble_hids;..\sdk_root\components\ble\ble_services\ble_hrs;..\sdk_root\components\ble\ble_services\ble_hrs_c;..\sdk_root\components\ble\ble_services\ble_hts;..\sdk_root\components\ble\ble_services\ble_ias;..\sdk_root\components\ble\ble_services\ble_ias_c;..\sdk_root\components\ble\ble_services\ble_lbs;..\sdk_root\components\ble\ble_services\ble_lbs_c;..\sdk_root\components\ble\ble_services\ble_lls;..\sdk_root\components\ble\ble_services\ble_nus;..\sdk_root\components\ble\ble_services\ble_nus_c;..\sdk_root\components\ble\ble_services\ble_rscs;..\sdk_root\components\ble\ble_services\ble_rscs_c;..\sdk_root\components\ble\ble_services\ble_tps;..\sdk_root\components\ble\common;..\sdk_root\components\ble\nrf_ble_qwr;..\sdk_root\components\ble\peer_manager;..\sdk_root\components\boards;..\sdk_root\components\drivers_nrf\adc;..\sdk_root\components\drivers_nrf\clock;..\sdk_root\components\drivers_nrf\common;..\sdk_root\components\drivers_nrf\comp;..\sdk_root\components\drivers_nrf\delay;..\sdk_root\components\drivers_nrf\gpiote;..\sdk_root\components\drivers_nrf\hal;..\sdk_root\components\drivers_nrf\i2s;..\sdk_root\components\drivers_nrf\lpcomp;..\sdk_root\components\drivers_nrf\pdm;..\sdk_root\components\drivers_nrf\power;..\sdk_root\components\drivers_nrf\ppi;..\sdk_root\components\drivers_nrf\pwm;..\sdk_root\components\drivers_nrf\qdec;..\sdk_root\components\drivers_nrf\rng;..\sdk_root\components\drivers_nrf\rtc;..\sdk_root\components\drivers_nrf\saadc;..\sdk_root\components\drivers_nrf\spi_master;..\sdk_root\components\drivers_nrf\spi_slave;..\sdk_root\components\drivers_nrf\swi;..\sdk_root\components\drivers_nrf\timer;..\sdk_root\components\drivers_nrf\twi_master;..\sdk_root\components\drivers_nrf\twis_slave;..\sdk_root\components\drivers_nrf\uart;..\sdk_root\components\drivers_nrf\usbd;..\sdk_root\components\drivers_nrf\wdt;..\sdk_root\components\libraries\bsp;..\sdk_root\components\libraries\button;..\sdk_root\components\libraries\crc16;..\sdk_root\components\libraries\crc32;..\sdk_root\components\libraries\csense;..\sdk_root\components\libraries\csense_drv;..\sdk_root\components\libraries\experimental_section_vars;..\sdk_root\components\libraries\fds;..\sdk_root\components\libraries\fstorage;..\sdk_root\components\libraries\gpiote;..\sdk_root\components\libraries\hardfault;..\sdk_root\components\libraries\hci;..\sdk_root\components\libraries\led_softblink;..\sdk_root\components\libraries\log;..\sdk_root\components\libraries\log\src;..\sdk_root\components\libraries\low_power_pwm;..\sdk_root\components\libraries\mem_manager;..\sdk_root\components\libraries\pwm;..\sdk_root\components\libraries\queue;..\sdk_root\components\libraries\scheduler;..\sdk_root\components\libraries\sensorsim;..\sdk_root\components\libraries\slip;..\sdk_root\components\libraries\timer;..\sdk_root\components\libraries\twi;..\sdk_root\components\libraries\uart;..\sdk_root\components\libraries\usbd;..\sdk_root\components\libraries\usbd\class\audio;..\sdk_root\components\libraries\usbd\class\cdc;..\sdk_root\components\libraries\usbd\class\cdc\acm;..\sdk_root\components\libraries\usbd\class\hid;..\sdk_root\components\libraries\usbd\class\hid\generic;..\sdk_root\components\libraries\usbd\class\hid\kbd;..\sdk_root\components\libraries\usbd\class\hid\mouse;..\sdk_root\components\libraries\usbd\class\msc;..\sdk_root\components\libraries\usbd\config;..\sdk_root\components\libraries\util;..\sdk_root\components\softdevice\common\softdevice_handler;..\sdk_root\components\softdevice\s130\headers;..\sdk_root\components\softdevice\s130\headers\nrf51;..\sdk_root\components\toolchain;..\sdk_root\external\segger_rtt;config;..\sdk_root\components\libraries\fifo
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF51422,-DBOARD_PCA10028,-DS130,-DNRF_SD_BLE_API_VERSION=2,-DNRF51,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\sdk_root\components;..\sdk_root\components\ble\ble_db_discovery;..\sdk_root\components\ble\ble_advertising;..\sdk_root\components\ble\ble_dtm;..\sdk_root\components\ble\ble_racp;..\sdk_root\components\ble\ble_services\ble_ancs_c;..\sdk_root\components\ble\ble_services\ble_ans_c;..\sdk_root\components\ble\ble_services\ble_bas;..\sdk_root\components\ble\ble_services\ble_bas_c;..\sdk_root\components\ble\ble_services\ble_cscs;..\sdk_root\components\ble\ble_services\ble_cts_c;..\sdk_root\components\ble\ble_services\ble_dfu;..\sdk_root\components\ble\ble_services\ble_dis;..\sdk_root\components\ble\ble_services\ble_gls;..\sdk_root\components\ble\ble_services\ble_hids;..\sdk_root\components\ble\ble_services\ble_hrs;..\sdk_root\components\ble\ble_services\ble_hrs_c;..\sdk_root\components\ble\ble_services\ble_hts;..\sdk_root\components\ble\ble_services\ble_ias;..\sdk_root\components\ble\ble_services\ble_ias_c;..\sdk_root\components\ble\ble_services\ble_lbs;..\sdk_root\components\ble\ble_services\ble_lbs_c;..\sdk_root\components\ble\ble_services\ble_lls;..\sdk_root\components\ble\ble_services\ble_nus;..\sdk_root\components\ble\ble_services\ble_nus_c;..\sdk_root\components\ble\ble_services\ble_rscs;..\sdk_root\components\ble\ble_services\ble_rscs_c;..\sdk_root\components\ble\ble_services\ble_tps;..\sdk_root\components\ble\common;..\sdk_root\components\ble\nrf_ble_qwr;..\sdk_root\components\ble\peer_manager;..\sdk_root\components\boards;..\sdk_root\components\drivers_nrf\adc;..\sdk_root\components\drivers_nrf\clock;..\sdk_root\components\drivers_nrf\common;..\sdk_root\components\drivers_nrf\comp;..\sdk_root\components\drivers_nrf\delay;..\sdk_root\components\drivers_nrf\gpiote;..\sdk_root\components\drivers_nrf\hal;..\sdk_root\components\drivers_nrf\i2s;..\sdk_root\components\drivers_nrf\lpcomp;..\sdk_root\components\drivers_nrf\pdm;..\sdk_root\components\drivers_nrf\power;..\sdk_root\components\drivers_nrf\ppi;..\sdk_root\components\drivers_nrf\pwm;..\sdk_root\components\drivers_nrf\qdec;..\sdk_root\components\drivers_nrf\rng;..\sdk_root\components\drivers_nrf\rtc;..\sdk_root\components\drivers_nrf\saadc;..\sdk_root\components\drivers_nrf\spi_master;..\sdk_root\components\drivers_nrf\spi_slave;..\sdk_root\components\drivers_nrf\swi;..\sdk_root\components\drivers_nrf\timer;..\sdk_root\components\drivers_nrf\twi_master;..\sdk_root\components\drivers_nrf\twis_slave;..\sdk_root\components\drivers_nrf\uart;..\sdk_root\components\drivers_nrf\usbd;..\sdk_root\components\drivers_nrf\wdt;..\sdk_root\components\libraries\bsp;..\sdk_root\components\libraries\button;..\sdk_root\components\libraries\crc16;..\sdk_root\components\libraries\crc32;..\sdk_root\components\libraries\csense;..\sdk_root\components\libraries\csense_drv;..\sdk_root\components\libraries\experimental_section_vars;..\sdk_root\components\libraries\fds;..\sdk_root\components\libraries\fstorage;..\sdk_root\components\libraries\gpiote;..\sdk_root\components\libraries\hardfault;..\sdk_root\components\libraries\hci;..\sdk_root\components\libraries\led_softblink;..\sdk_root\components\libraries\log;..\sdk_root\components\libraries\log\src;..\sdk_root\components\libraries\low_power_pwm;..\sdk_root\components\libraries\mem_manager;..\sdk_root\components\libraries\pwm;..\sdk_root\components\libraries\queue;..\sdk_root\components\libraries\scheduler;..\sdk_root\components\libraries\sensorsim;..\sdk_root\components\libraries\slip;..\sdk_root\components\libraries\timer;..\sdk_root\components\libraries\twi;..\sdk_root\components\libraries\uart;..\sdk_root\components\libraries\usbd;..\sdk_root\components\libraries\usbd\class\audio;..\sdk_root\components\libraries\usbd\class\cdc;..\sdk_root\components\libraries\usbd\class\cdc\acm;..\sdk_root\components\libraries\usbd\class\hid;..\sdk_root\components\libraries\usbd\class\hid\generic;..\sdk_root\components\libraries\usbd\class\hid\kbd;..\sdk_root\components\libraries\usbd\class\hid\mouse;..\sdk_root\components\libraries\usbd\class\msc;..\sdk_root\components\libraries\usbd\config;..\sdk_root\components\libraries\util;..\sdk_root\components\softdevice\common\softdevice_handler;..\sdk_root\components\softdevice\s130\headers;..\sdk_root\components\softdevice\s130\headers\nrf51;..\sdk_root\components\toolchain;..\sdk_root\external\segger_rtt;config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x200025e0 size 0x5a20
  group Application
    ../src/: main.c per.c cen.c util_misc.c util_app.c Fuel_Gauge.c LED.c Button.c Detect.c Sensor_Communication.c
    config/: sdk_config.h
  group Board Definition
    ../sdk_root/components/boards/: boards.c
  group Documentation
    ../: license.txt
  group nRF_BLE
    ../sdk_root/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../sdk_root/components/ble/ble_advertising/: ble_advertising.c
    ../sdk_root/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../sdk_root/components/ble/ble_db_discovery/: ble_db_discovery.c
  group nRF_Drivers
    ../sdk_root/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../sdk_root/components/drivers_nrf/common/: nrf_drv_common.c
    ../sdk_root/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../sdk_root/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../sdk_root/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../sdk_root/components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../sdk_root/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../sdk_root/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../sdk_root/components/drivers_nrf/timer/: nrf_drv_timer.c
  group nRF_Libraries
    ../sdk_root/components/libraries/button/: app_button.c
    ../sdk_root/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../sdk_root/components/libraries/timer/: app_timer.c
    ../sdk_root/components/libraries/crc16/: crc16.c
    ../sdk_root/components/libraries/fds/: fds.c
    ../sdk_root/components/libraries/fstorage/: fstorage.c
    ../sdk_root/components/libraries/hardfault/: hardfault_implementation.c
    ../sdk_root/components/libraries/sensorsim/: sensorsim.c
    ../sdk_root/components/libraries/twi/: app_twi.c
    ../sdk_root/components/libraries/pwm/: app_pwm.c
    ../src/: app_gpiote.c
    ../sdk_root/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../sdk_root/components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../sdk_root/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../sdk_root//external/segger_rtt/: RTT_Syscalls_KEIL.c
    ../sdk_root/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../sdk_root/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s130_nrf51_2.0.1_softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s130_nrf51_2.0.1_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_template_pca10028_s130;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x6018
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
